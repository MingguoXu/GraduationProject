# Keil uVision project 喷雾系统.uvprojx, settings and files
target XMG (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 喷雾系统 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\STM32F10x_FWLIB\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\TIMER;..\HARDWARE\ADDA;..\HARDWARE\Control;..\HARDWARE\Driver;..\HARDWARE\KEY;..\HARDWARE\LCDDriver;..\HARDWARE\LED;..\HARDWARE\Scope;..\HARDWARE\STMFLASH;..\HARDWARE\IO
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/ADDA/: adda.c
    ../HARDWARE/Control/: Control.c
    ../HARDWARE/KEY/: KEY.C
    ../HARDWARE/LED/: led.c
    ../HARDWARE/Driver/: EdpKit.c esp8266.c onenetusart.c
    ../HARDWARE/LCDDriver/: HzLib_65k.c ili9320.c ili9320_api.c TOUCH_SPI2.c
    ../HARDWARE/Scope/: scope.c
    ../HARDWARE/STMFLASH/: stmflash.c
    ../HARDWARE/IO/: io.c
  group FWLIB
    ../STM32F10x_FWLIB/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_dac.c stm32f10x_exti.c stm32f10x_spi.c stm32f10x_fsmc.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
